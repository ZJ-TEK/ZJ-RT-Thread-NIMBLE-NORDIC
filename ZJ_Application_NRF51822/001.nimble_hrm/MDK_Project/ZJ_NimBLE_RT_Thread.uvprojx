# Keil uVision project ZJ_NimBLE_RT_Thread.uvprojx, settings and files
target ZJ_NimBLE_RT_Thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: zj_nimble_rtthread +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_ARM_LIBC  NIMBLE_CFG_CONTROLLER=1 NRF51 RETARGET_ENABLED
  c misc: --reduce_paths --gnu
  c include: ..\..\..\NORDIC_HAL\nrfx;..\..\..\NORDIC_HAL\nrfx\drivers;..\..\..\NORDIC_HAL\nrfx\drivers\include;..\..\..\NORDIC_HAL\nrfx\drivers\src\prs;..\..\..\NORDIC_HAL\nrfx\hal;..\..\..\NORDIC_HAL\nrfx\mdk;..\..\..\NORDIC_HAL\nrfx\soc;..\..\..\NORDIC_HAL\segger_rtt;..\..\..\Mynewt_NimBLE;..\..\..\Mynewt_NimBLE\nimble\include;..\..\..\Mynewt_NimBLE\nimble\host\include;..\..\..\Mynewt_NimBLE\nimble\host\src;..\..\..\Mynewt_NimBLE\nimble\host\services\ans\include;..\..\..\Mynewt_NimBLE\nimble\host\services\bas\include;..\..\..\Mynewt_NimBLE\nimble\host\services\bleuart\include;..\..\..\Mynewt_NimBLE\nimble\host\services\gap\include;..\..\..\Mynewt_NimBLE\nimble\host\services\gatt\include;..\..\..\Mynewt_NimBLE\nimble\host\services\ias\include;..\..\..\Mynewt_NimBLE\nimble\host\services\lls\include;..\..\..\Mynewt_NimBLE\nimble\host\services\tps\include;..\..\..\Mynewt_NimBLE\nimble\host\store\ram\include;..\..\..\Mynewt_NimBLE\nimble\host\util\include;..\..\..\Mynewt_NimBLE\porting\nimble\include;..\..\..\Mynewt_NimBLE\porting\npl\rtthread\include;..\..\..\Mynewt_NimBLE\ext\tinycrypt\include;..\..\..\Mynewt_NimBLE\nimble\transport\ram\include;..\..\..\Mynewt_NimBLE\nimble\controller\include;..\..\..\Mynewt_NimBLE\nimble\drivers\nrf51\include;..\..\..\Mynewt_NimBLE\apps\blehr\src;..\..\..\RT_THREAD\components\CMSIS\Include;..\..\..\RT_THREAD\include;..\..\..\RT_THREAD\libcpu\arm\common;..\..\..\RT_THREAD\libcpu\arm\cortex-m0;..\..\..\RT_THREAD\components\dfs\include;..\..\..\RT_THREAD\components\dfs\filesystems\devfs;..\..\..\RT_THREAD\components\drivers\include;..\..\..\RT_THREAD\components\finsh;..\..\..\RT_THREAD\components\libc\compilers\armlibc;..\..\..\RT_THREAD\components\libc\compilers\common;..\config;..\applications;..\RT_Thread_Startup;..\nordic_misc;..\applications\app_init;..\applications\app_event
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group application
    ../applications/app_init/: app_init.c
    ../applications/app_event/: app_event.c
    ../config/: rtconfig.h
  group nimble_application
    ../../../Mynewt_NimBLE/apps/blehr/src/: blehr.c
  group nimble_servers
    ../../../Mynewt_NimBLE/apps/blehr/src/: gatt_svr.c
  group nimble_host
    ../../../Mynewt_NimBLE/nimble/host/src/: ble_att.c ble_att_clt.c ble_att_cmd.c ble_att_svr.c ble_eddystone.c ble_gap.c ble_gattc.c ble_gatts.c ble_gatts_lcl.c ble_hs_adv.c ble_hs.c ble_hs_atomic.c ble_hs_cfg.c ble_hs_conn.c ble_hs_dbg.c ble_hs_flow.c ble_hs_hci.c ble_hs_hci_cmd.c ble_hs_hci_evt.c ble_hs_hci_util.c ble_hs_id.c ble_hs_log.c ble_hs_mbuf.c ble_hs_mqueue.c ble_hs_misc.c ble_hs_pvcy.c ble_hs_startup.c ble_hs_stop.c ble_ibeacon.c ble_l2cap.c ble_l2cap_coc.c ble_l2cap_sig.c ble_l2cap_sig_cmd.c ble_monitor.c ble_sm_alg.c ble_sm.c ble_sm_cmd.c ble_sm_lgcy.c ble_sm_sc.c ble_store.c ble_store_util.c ble_uuid.c
    ../../../Mynewt_NimBLE/nimble/host/services/ans/src/: ble_svc_ans.c
    ../../../Mynewt_NimBLE/nimble/host/services/bas/src/: ble_svc_bas.c
    ../../../Mynewt_NimBLE/nimble/host/services/bleuart/src/: ble_svc_uart.c
    ../../../Mynewt_NimBLE/nimble/host/services/gap/src/: ble_svc_gap.c
    ../../../Mynewt_NimBLE/nimble/host/services/gatt/src/: ble_svc_gatt.c
    ../../../Mynewt_NimBLE/nimble/host/services/ias/src/: ble_svc_ias.c
    ../../../Mynewt_NimBLE/nimble/host/services/lls/src/: ble_svc_lls.c
    ../../../Mynewt_NimBLE/nimble/host/services/tps/src/: ble_svc_tps.c
    ../../../Mynewt_NimBLE/nimble/host/store/ram/src/: ble_store_ram.c
    ../../../Mynewt_NimBLE/nimble/host/util/src/: addr.c
  group nimble_controller
    ../../../Mynewt_NimBLE/nimble/controller/src/: ble_ll_sched.c ble_ll_xcvr.c ble_ll_whitelist.c ble_ll_ctrl.c ble_ll_hci.c ble_ll_supp_cmd.c ble_ll_adv.c ble_ll_conn.c ble_ll_resolv.c ble_ll_conn_hci.c ble_ll_rand.c ble_ll.c ble_ll_scan.c ble_ll_dtm.c ble_ll_hci_ev.c
  group nimble_port
    ../../../Mynewt_NimBLE/porting/nimble/src/: nimble_port.c endian.c mem.c os_mbuf.c os_mempool.c os_msys_init.c os_cputime.c os_cputime_pwr2.c hal_timer.c
    ../../../Mynewt_NimBLE/porting/npl/rtthread/src/: modlog.c nimble_port_rtthread.c npl_os_rtthread.c npl_shell.c nrf5x_isr.c
  group nimble_tinycrypt
    ../../../Mynewt_NimBLE/ext/tinycrypt/src/: aes_decrypt.c aes_encrypt.c cmac_mode.c ecc.c ecc_dh.c utils.c
  group nimble_misc_phy
    ../../../Mynewt_NimBLE/nimble/transport/ram/src/: ble_hci_ram.c
    ../../../Mynewt_NimBLE/nimble/src/: ble_util.c
    ../../../Mynewt_NimBLE/nimble/drivers/nrf51/src/: ble_hw.c ble_phy.c
  group rtthread_startup
    ../RT_Thread_Startup/: board.c
  group rtthread_kernel
    ../../../RT_THREAD/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group cortex_m0
    ../../../RT_THREAD/libcpu/arm/cortex-m0/: cpuport.c context_rvds.s
  group arm_libc
    ../../../RT_THREAD/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../../../RT_THREAD/components/libc/compilers/common/: gmtime_r.c
  group nrf_hal
    ../../../NORDIC_HAL/nrfx/mdk/: arm_startup_nrf51.s system_nrf51.c
    ../../../NORDIC_HAL/nrfx/drivers/src/: nrfx_clock.c nrfx_power.c nrfx_rtc.c
    ../nordic_misc/: nrfx_glue.c
  group nrf_segger_rtt
    ../../../NORDIC_HAL/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Device.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group DeviceDriver
    ../../../RT_THREAD/components/drivers/src/: completion.c dataqueue.c ringbuffer.c
    ../../../RT_THREAD/components/drivers/serial/: serial.c
    ../../../RT_THREAD/components/drivers/misc/: pin.c
  group finsh_shell
    ../../../RT_THREAD/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
